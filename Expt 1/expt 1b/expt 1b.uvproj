# Keil uVision project expt 1b.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: expt 1b
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: expt 1b.asm
